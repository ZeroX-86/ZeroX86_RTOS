# Keil uVision project printf.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Exercise4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: __DO_NOT_LINK_PROMISE_WITH_ASSERT, __ASSERT_MSG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\CustomLinker.sct
  group Source
    ./: main.c SysTick.c tsk.c tsk_10ms.c tsk_100ms.c tsk_cfg.c button.c uart.c uart_config.c uart_app.c wdt.c wdt_config.c
  group Headers
    ./: SysTick.h button.h uart.h uart_config.h uart_app.h cbuf.h wdt.h wdt_config.h
software components: CMSIS:CORE 4.1.0, Board Support:LED 1.0.0, Device:Startup 1.0.0
